# Keil uVision project shixun.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: shixun +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1602.c delay.c uart.c main.c DHT11.c fengmingqi.c 24c02.c
